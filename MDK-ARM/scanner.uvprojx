# Keil uVision project scanner.uvprojx, settings and files
target scanner (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: scanner +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_USB_HS
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;..\source_from_yuanzi;..\source_from_yuanzi\DCMI;..\source_from_yuanzi\KEY;..\source_from_yuanzi\LCD;..\source_from_yuanzi\MALLOC;..\source_from_yuanzi\OV5640;..\source_from_yuanzi\SDRAM;..\source_from_yuanzi\SYSTEM\delay;..\source_from_yuanzi\SYSTEM\sys;..\source_from_yuanzi\SYSTEM\usart;..\source_from_yuanzi\PCF8574;..\source_from_yuanzi\IIC;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\DSP_LIB\Include;..\source_from_yuanzi;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c gpio.c usb_device.c usbd_conf.c usbd_desc.c stm32f4xx_it.c stm32f4xx_hal_msp.c usbd_cdc_if.c CRC.c
    ../source_from_yuanzi/: emwin_JHE.c emwin_demo.c ScannerDLG.c uploadDLG.c uploadsucessDLG.c
    ../: Logo_frame.c Scanning_frame.c Scanning_Line.c Leica_logo_starting.c scanning_pic2.c ok.c err.c colorbands.c err2.c ok2.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_iwdg.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group source_from_yuanzi
    ../source_from_yuanzi/DCMI/: dcmi.c
    ../source_from_yuanzi/KEY/: key.c
    ../source_from_yuanzi/LCD/: ltdc.c ILI9341.c
    ../source_from_yuanzi/MALLOC/: malloc.c
    ../source_from_yuanzi/OV5640/: sccb.c ov5640.c
    ../source_from_yuanzi/SDRAM/: sdram.c
    ../source_from_yuanzi/SYSTEM/delay/: delay.c
    ../source_from_yuanzi/SYSTEM/sys/: sys.c
    ../source_from_yuanzi/: function.c
    ../source_from_yuanzi/PCF8574/: pcf8574.c
    ../source_from_yuanzi/IIC/: myiic.c
    ../source_from_yuanzi/SYSTEM/usart/: usart.c
  group emwin
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c LCDConf_Lin_Template.c GUI_X_Touch_Analog.c
    ../EMWIN/STemWin/Lib/: GUI_CM4F_L.lib
    ../EMWIN/STemWin/OS/: GUI_X.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
    ../DSP_LIB/Include/: arm_math.h
software components: CMSIS:CORE 5.0.1
